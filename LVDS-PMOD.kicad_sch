File: LVDS-PMOD.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: v1
Other:
- company: (none) -> MIT
- title: (none) -> LVDS Quad PMOD
